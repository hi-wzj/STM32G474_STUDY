# Keil uVision project StudyMax.uvprojx, settings and files
target StudyMax (6220000::V6.22::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StudyMax +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ..\MIDDLEWARS\STM32G4xx_HAL_Driver\CMSIS\Device\ST\STM32G4xx\Include;..\MIDDLEWARS\STM32G4xx_HAL_Driver\CMSIS\Include;..\MIDDLEWARS\STM32G4xx_HAL_Driver\Inc;..\USERS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../MIDDLEWARS/STM32G4xx_HAL_Driver/: startup_stm32g474xx.s
  group Users
    ../USERS/: main.c stm32g4xx_it.c
  group Dirvers
    ../MIDDLEWARS/Drivers/LED/: led.c
    ../MIDDLEWARS/Drivers/SPI/: spi.c
    ../MIDDLEWARS/Drivers/LCD/: lcd.c
  group STM32G4xx_HAL_Driver
    ../MIDDLEWARS/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_wwdg.c stm32g4xx_hal_spi.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../MIDDLEWARS/STM32G4xx_HAL_Driver/CMSIS/Device/ST/STM32G4xx/Source/: system_stm32g4xx.c
  group Usmart
    ../MIDDLEWARS/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
